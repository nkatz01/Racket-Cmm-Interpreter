k = 1
while (k <= 3) k = k + 1
print k